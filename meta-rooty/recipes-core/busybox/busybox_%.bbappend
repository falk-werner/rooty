FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# SRC_URI:append = "file://<some>.cfg"
